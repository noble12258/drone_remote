# Keil uVision project remote.uvprojx, settings and files
target remote (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: perfei_remote +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\cmsis\inc;..\driver;..\stm32_lib\inc;..\module;..\protocol;..\system;..\rtthread;..\rtthread\include;..\my_lib
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group user
    ./: main.c startup_stm32f10x_md.s
  group system
    ../system/: flash.c nvic.c systick.c timer.c
  group module
    ../module/: oled_display.c pair_freq.c transmit_packet.c receive_packet.c remote_calibrate.c power_control.c key_handle.c led_status.c voltage_detect.c remote.c task_manage.c cpu_usage.c
  group driver
    ../driver/: led.c oled.c OledFont.c si24r1.c key.c beep.c
  group protocol
    ../protocol/: adc.c i2c.c spi.c usart.c gpio.c
  group my_lib
    ../my_lib/: filter_lib.c log_lib.c math_lib.c my_lib.c queue_lib.c shell_lib.c crc_lib.c
  group stm32_lib
    ../stm32_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group cmsis
    ../cmsis/src/: core_cm3.c system_stm32f10x.c stm32f10x_it.c
  group rt_thread
    ../rtthread/src/: clock.c components.c cpu.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
    ../rtthread/: board.c
    ../rtthread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
